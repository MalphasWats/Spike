# Repository MalphasWats/Spike

File README.md:

# Spike

Spike is a handheld gaming console based on ATMega Microcontrollers.

I've been playing around with this idea for a long while and the Spike is the current 'state-of-the-art' for me.

The main spike board has:

* 128x64px monochrome OLED display
* Piezo speaker
* 7 buttons (plus reset)
* 3.7v Lipo battery
* Micro-USB port for charging & data

The *shard* board provides the brains and connects via an edge connector on the back of the main board.

Currently I'm using an ATMega1284p running at 16MHz.

I've written a little [more detail on my blog](http://www.subdimension.co.uk/2019/01/16/spike-next-gen-portable-gaming.html).

## KiCad design shard/shard.kicad_pcb

Board: 2 copper layers, 35.0 x 31.0 mm, 4 parts (0 on the bottom side), 3 nets, no tracks yet.

Parts:
C0: 104; C_Rect_L7.0mm_W2.5mm_P5.00mm
J0: Shard; Samtec_MEC8-120-02-L-D-RA1_Edge
J1: ISP; PinHeader_2x03_P2.54mm_Vertical
SPIKE: SPIKE

Connections:
+3V3: C0.1, J0.2, J1.2
GND: C0.2, J0.40, J1.6
RESET: J0.16, J1.5

## KiCad design shard_t84/shard.kicad_pcb

Parts:
C0, C1: 104; C_Rect_L7.0mm_W2.5mm_P5.00mm
D1: D_ALT; D_A-405_P7.62mm_Horizontal
J0: Shard; Samtec_MEC8-120-02-L-D-RA1_Edge
J1: ISP; PinHeader_2x03_P2.54mm_Vertical
R1: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: ATtiny84-20PU; DIP-14_W7.62mm

Connections:
+3V3: C0.1, D1.1 (K), J0.2, J1.2, R1.1, U1.1 (VCC)
BTN_A: J0.8, U1.5 (PB2)
BTN_B: J0.10, U1.3 (XTAL2/PB1)
BTN_C: J0.12, U1.2 (XTAL1/PB0)
DOWN: J0.34, U1.11 (PA2)
D_DC: J0.22, J1.1, U1.8 (PA5)
D_MOSI: J0.26, J1.4, U1.7 (PA6)
D_RST: C1.2, D1.2 (A), J0.16, J0.24, J1.5, R1.2, U1.4 (~RESET~/PB3)
D_SCK: J0.28, J1.3, U1.9 (PA4)
GND: C0.2, C1.1, J0.4, J0.6, J0.20, J0.40, J1.6, U1.14 (GND)
LEFT: J0.36, U1.12 (PA1)
RIGHT: J0.38, U1.13 (AREF/PA0)
SND: J0.30, U1.6 (PA7)
UP: J0.32, U1.10 (PA3)

Board: 2 copper layers, 35.0 x 31.0 mm, 8 parts (0 on the bottom side), 14 nets.

Other parts of the board:
SPIKE: SPIKE

## KiCad design board.kicad_pcb

Parts:
C1: 104; C_Rect_L7.0mm_W2.5mm_P5.00mm
C2, C3: 105; C_Rect_L7.0mm_W2.5mm_P5.00mm
C5, C6: 475; C_Rect_L7.0mm_W2.5mm_P5.00mm
D1: CHG; LED_D3.0mm
J0: Battery Pads; LiPo_Pads
J1: Shard; Samtec_MEC8-120-02-L-D-RA1_Socket
J2: USB-Micro; USB_Micro-B_Molex-105017-0001
LS1: Speaker; Generic_Speaker
R0: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R1: LED; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW0: RESET; SW_PUSH_6mm
SW1: UP; SW_PUSH_6mm
SW2: DOWN; SW_PUSH_6mm
SW3: LEFT; SW_PUSH_6mm
SW4: RIGHT; SW_PUSH_6mm
SW5: BTN_A; SW_PUSH_6mm
SW6: BTN_B; SW_PUSH_6mm
SW7: BTN_C; SW_PUSH_6mm
SW8: POWER; SW_DIP_SPSTx01_Slide_9.78x4.72mm_W7.62mm_P2.54mm
U1: OLED; 128x64-OLED
U2: CHG CTRL; SOT-23-5
U3: Reg; SOT-23

Connections:
+3V3: C1.1, C3.1, J1.2, R0.1, U1.2, U3.2 (VO)
+BATT: C6.1, J0.1, SW8.2 (B), U2.3 (VBAT)
BTN_A: J1.8, SW5.2
BTN_B: J1.10, SW6.2
BTN_C: J1.12, SW7.2
CHARGE: C5.1, D1.2 (A), J2.1 (VBUS), U2.4 (VDD)
D+: J1.6, J2.3 (D+)
D-: J1.4, J2.2 (D-)
DOWN: J1.34, SW2.2
D_CS: J1.20, U1.7
D_DC: J1.22, U1.6
D_MOSI: J1.26, U1.4
D_RST: J1.24, U1.5
D_SCK: J1.28, U1.3
GND: C1.2, C2.2, C3.2, C5.2, C6.2, J0.2, J1.40, J2.4 (ID), J2.5 (GND), J2.6 (Shield), LS1.1, R2.2, SW0.1, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, U1.1, U2.2 (VSS), U3.1 (GND)
LEFT: J1.36, SW3.2
unnamed: C2.1, SW8.1 (A), U3.3 (VI)
unnamed: D1.1 (K), R1.2
unnamed: R1.1, U2.1 (STAT)
unnamed: R2.1, U2.5 (PROG)
RESET: J1.16, R0.2, SW0.2
RIGHT: J1.38, SW4.2
SND: J1.30, LS1.2
UP: J1.32, SW1.2

Board: 2 copper layers, 85.3 x 35.3 mm, 28 parts (4 on the bottom side), 24 nets.

Other parts of the board:
LOGO: LOGO
SPIKE: SPIKE
SPIKE#2: SPIKE

## KiCad design shard_1284/shard.kicad_pcb

Parts:
C0: 104; C_Rect_L7.0mm_W2.5mm_P5.00mm
C1, C2: 220; C_Rect_L7.0mm_W2.5mm_P5.00mm
J0: Shard; Samtec_MEC8-120-02-L-D-RA1_Edge
J1: ISP; PinHeader_2x03_P2.54mm_Vertical
U1: ATmega1284P-MU; TQFP-44_10x10mm_P0.8mm
Y1: 16MHz; Resonator-2Pin_W10.0mm_H5.0mm

Connections:
+3V3: C0.1, J0.2, J1.2, U1.5 (VCC), U1.17 (VCC), U1.27 (AVCC), U1.38 (VCC)
BTN_A: J0.8, U1.21 (PC2)
BTN_B: J0.10, U1.20 (PC1)
BTN_C: J0.12, U1.19 (PC0)
DOWN: J0.34, U1.24 (PC5)
D_CS: J0.20, U1.41 (PB1)
D_DC: J0.22, U1.43 (PB3)
D_MOSI: J0.26, U1.9 (PD0), U1.10 (PD1)
D_RST: J0.24, U1.42 (PB2)
D_SCK: J0.28, U1.40 (PB0)
GND: C0.2, C1.2, C2.2, J0.4, J0.6, J0.40, J1.6, U1.6 (GND), U1.18 (GND), U1.28 (GND), U1.39 (GND)
LEFT: J0.36, U1.23 (PC4)
MISO: J1.1, U1.2 (PB6)
MOSI: J1.4, U1.1 (PB5)
unnamed: C1.1, U1.8 (XTAL1), Y1.2
unnamed: C2.1, U1.7 (XTAL2), Y1.1
RESET: J0.16, J1.5, U1.4 (~RESET)
RIGHT: J0.38, U1.22 (PC3)
SCK: J1.3, U1.3 (PB7)
SND: J0.30, U1.14 (PD5)
UP: J0.32, U1.25 (PC6)

Board: 2 copper layers, 35.0 x 31.0 mm, 8 parts (1 on the bottom side), 21 nets.

Other parts of the board:
SPIKE: SPIKE

## Commit log

2018-09-27 initial import
2018-09-28 Updated Layout
2018-10-03 Added tracks
2018-10-05 tweak
2018-10-08 Logo
2018-10-09 added crystal
2018-10-09 Revert "added crystal"
    This reverts commit 60f505991b0e3ccfce5c63fb45a6584053ac2d9c.
2018-10-09 Changed labels
2018-10-09 Revert "Revert "added crystal""
    This reverts commit 7f3a5123c106fe465dc47a4e88f841c035e49e56.
2018-10-09 sorted crystal
    I think. Got into a proper pickle there.
2018-10-16 crystal I think
2018-10-28 reworked to be MCU agnostic
2018-10-28 basic shard template
2018-10-28 Shard_1284 initial implementation
2018-10-28 t84 shard
2018-10-29 added mounting holes
2018-10-30 shard template fixed
2018-10-30 added capacitor value
2018-10-30 disconnected D- & D+ to fix GND net
2018-10-30 reworked board for correct connector orientation
2018-11-11 board revised for mono oled
2018-11-11 t84 shard updated for new layout
2018-11-11 swapped buttons to pull to GND
2018-11-12 flip connector
2018-11-12 Edge Connector for Shards
2018-11-12 updated for edge connector
2018-11-13 Board updated to edge connector
2018-11-13 Template updated to edge connector
2018-11-13 outline updated
2018-11-13 1284 shard updated to edge connector
2018-11-14 changed 3.3v track to via instead of mounting point
2018-11-15 label tweaks
2018-11-15 flipped logo to match shard
2018-11-15 tweaked labels
2018-11-16 Added 1284 makefile
2019-01-24 simple case idea
2019-01-24 this one didn't work out
2019-01-26 Revert "this one didn't work out"
    This reverts commit 10e7dd97264609a345ca62be13df3977391ce221.
2019-01-26 fixed issues with shard
2019-01-26 ::eyeroll::
2019-01-27 button cap
2019-01-30 top case
2019-01-30 little bit extra
2019-01-30 tweak size
2019-02-04 ignoring some things
